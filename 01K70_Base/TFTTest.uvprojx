# Keil uVision project TFTTest.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK70FN1M0xxx12 NXP
  pack: Keil.Kinetis_K70_DFP.1.1.0
  cpu: IROM(0x00000000,0x00100000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K70_TFTM035
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Main
    ./: main_file.c
  group Drivers
    ./: SPI_HLD.c LPTimer_LDD.c
  group Modules
    ./: Delays.c ILI9488_Display.c TouchPanel.c MultiFunctionBus.c LCDLatchingHandler.c SDCard.c FontChip.c TFT_Flash.c TouchPanelCalibration.c AlternateMethodsForTouchDetection.c
  group Resources
    ./: Images.c Font.c Converters.c
  group Configurations
    ./: UserConfig.h
  group ::Device
    RTE/Device/MK70FN1M0xxx12/: startup_MK70F12.s system_MK70F12.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
